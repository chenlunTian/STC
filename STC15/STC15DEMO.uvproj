# Keil uVision project STC15DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\User
  group user
    ./User/: main.c headfile.h
  group lib
    ./lib/: adc.c ascii.c delay.c gb1616.c gb3232.c hmc5883l.c image0.c int.c interrupt.c lcd.c lkb.c mpu6050.c nrf24l01.c pca_pwm.c timer.c uart.c
  group doc
    ./Doc/: readme.txt
